# Keil uVision project bpsk-modulator.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bpsk-modulator +hex
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: DEBUG_MCU_SYSCLK
  c include: .\inc;.\inc\arch;.\inc\drivers
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group main-group
    ./src/: dac-samples.c main.c
    ./inc/: dac-samples.h
  group arch
    ./inc/arch/: datasheet-constants.h gpio.h mcu.h rcc.h system-timer.h
    ./src/arch/: gpio.c rcc.c system-timer.c
  group board
    ./src/: initialization.c
    ./inc/: initialization.h config-macros.h config.h
  group drivers
    ./inc/drivers/: dma.h generator.h
    ./src/drivers/: dma.c generator.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP:Compute Graph Static Flow 1.14.2, Device:Startup 2.6.3
